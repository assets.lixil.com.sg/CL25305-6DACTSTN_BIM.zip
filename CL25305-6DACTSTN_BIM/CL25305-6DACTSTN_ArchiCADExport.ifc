Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-19T16:02:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.90.15 - Exporter 21.1.90.15 - Alternate UI 21.1.90.15
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 19 16:02:54 2024 * Host: DCreative * Database: C:\Users\chatp\AppData\Local\Temp\e660e992-9e87-4d52-8193-66490bc76ca2\49bd25b9-a533-47a3-85d1-04589d92880f\ifc * Database version: 5507 * Database creation date: Mon Aug 19 16:02:52 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 19 16:02:52 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 19 16:02:52 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcDistributionPort (2)
Description: Flow
Name | FlowDirection
Port_348389 | SINK
Port_348389 | SOURCE

# IfcFlowTerminal: CL26305-6DACTSTNF_REVIT:Flexio One Piece ST 3/4.5L comp. WT, CL26305-6DACTSTNF_REVIT:Flexio One Piece ST 3/4.5L comp. WT:348389
In: Level 1
Type - Material: White
Type - Pset_ManufacturerTypeInformation - Manufacturer: American Standard
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: Flexio One Piece ST 3/4.5L comp. WT
Material: White, Steel, Chrome Plated
Pset_DistributionFlowElementCommon - Reference: Flexio One Piece ST 3/4.5L comp. WT; sets with these values: 2
